# Keil uVision project RM2016 Infantry.uvproj, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: RM2016_Infantry +hex
  AfterMake: fromelf.exe  --bin -o ./bin/RM2016_Infantry.bin ./Outputs/RM2016_Infantry.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: .\BSP;.\APP;.\STLibraries;.\User;.\MPU6050;.\Protocol;.\FIFO;.\;.\Debug;.\RmLib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c
  group BSP
    ./BSP/: bsp.c led.c gun.c can1.c can2.c delay.c exti.c laser.c timer.c usart1.c usart3.c encoder.c bsp_flash.c
  group Libraries
    ./STLibraries/: startup_stm32f4xx.s misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c system_stm32f4xx.c stm32f4xx_i2c.c
    ./User/: stm32f4xx_it.c
  group MPU6050
    ./MPU6050/: imu.c mpu6050_i2c.c mpu6050_driver.c mpu6050_interrupt.c
  group Task
    ./APP/: ControlTask.c RemoteTask.c SuperviseTask.c Can1BusTask.c Can2BusTask.c arm_control.c
